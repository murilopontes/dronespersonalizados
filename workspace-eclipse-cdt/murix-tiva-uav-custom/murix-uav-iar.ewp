# IAR project murix-uav-iar.ewp, settings and files
configuration debug-iar (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: src; src\app; src\app-freertos; src\bitlash; src\freertos\include; src\freertos\portable\IAR\ARM_CM4F; src\lm4f\cores\lm4f; src\lm4f\libraries\EEPROM; src\lm4f\libraries\SPI; src\lm4f\libraries\Wire; src\lm4f\variants\stellarpad
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: murix-uav-iar.srec
  ILINK.IlinkOutputFile: murix-uav-iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src/app
    src/app/: cc1101.cpp cc1101.h cc1101_regs.h GY521.cpp GY521.h murix_pid.cpp murix_pid.h murixdrone.cpp murixdrone.h sketch.cpp
  group src/app-freertos
    src/app-freertos/: FreeRTOSConfig.h prvGetRegistersFromStack.cpp prvGetRegistersFromStack.h vApplicationStackOverflowHook.cpp
  group src/bitlash
    src/bitlash/: bitlash.cpp bitlash.h
  group src/freertos
    src/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group src/freertos/portable/IAR/ARM_CM4F
    src/freertos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group src/freertos/portable/memmang
    src/freertos/portable/MemMang/: heap_4.c
  group src/lm4f/cores/lm4f
    src/lm4f/cores/lm4f/: Arduino.h binary.h Client.h Energia.h HardwareSerial.cpp HardwareSerial.h IPAddress.cpp IPAddress.h itoa.c itoa.h main.cpp new.cpp new.h Print.cpp Print.h Printable.h random.c startup_gcc.c Stream.cpp Stream.h Tone.cpp WCharacter.h WInterrupts.c wiring.c wiring_analog.c wiring_digital.c wiring_private.h wiring_pulse.c wiring_shift.c WMath.cpp WString.cpp WString.h
  group src/lm4f/cores/lm4f/drivelib
    src/lm4f/cores/lm4f/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h epi_workaround_ccs.s flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group src/lm4f/cores/lm4f/inc
    src/lm4f/cores/lm4f/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h lm4f120h5qr.h tm4c123gh6pm.h
  group src/lm4f/libraries/EEPROM
    src/lm4f/libraries/EEPROM/: EEPROM.cpp EEPROM.h
  group src/lm4f/libraries/SPI
    src/lm4f/libraries/SPI/: SPI.cpp SPI.h
  group src/lm4f/libraries/Wire
    src/lm4f/libraries/Wire/: Wire.cpp Wire.h
  group src/lm4f/variants/stellarpad
    src/lm4f/variants/stellarpad/: pins_energia.h
