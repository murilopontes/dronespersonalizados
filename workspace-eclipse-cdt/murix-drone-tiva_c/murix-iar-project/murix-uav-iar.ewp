# IAR project murix-uav-iar.ewp, settings and files
configuration debug-iar (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: src; src\app; src\app-freertos; src\bitlash; src\freertos\include; src\freertos\portable\IAR\ARM_CM4F; src\lm4f\cores\lm4f; src\lm4f\libraries\EEPROM; src\lm4f\libraries\SPI; src\lm4f\libraries\Wire; src\lm4f\variants\stellarpad
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: murix-uav-iar.srec
  ILINK.IlinkOutputFile: murix-uav-iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
