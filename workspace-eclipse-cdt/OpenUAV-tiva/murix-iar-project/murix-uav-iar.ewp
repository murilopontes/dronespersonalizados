# IAR project murix-uav-iar.ewp, settings and files
configuration debug-iar (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: F_CPU=80000000L; ARDUINO=101; ENERGIA=11; ewarm
  ICCARM.CCIncludePath2: ..\src\murix; ..\src\bitlash; ..\src\freertos\include; ..\src\freertos\portable\IAR\ARM_CM4F; ..\src\lm4f\cores\lm4f; ..\src\lm4f\libraries\EEPROM; ..\src\lm4f\libraries\SPI; ..\src\lm4f\libraries\Wire; ..\src\lm4f\libraries\AIR_BOOST_433; ..\src\lm4f\variants\stellarpad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: F_CPU=80000000L; ARDUINO=101; ENERGIA=11; ewarm
  AARM.AUserIncludes: ..\src\murix; ..\src\bitlash; ..\src\freertos\include; ..\src\freertos\portable\IAR\ARM_CM4F; ..\src\lm4f\cores\lm4f; ..\src\lm4f\libraries\EEPROM; ..\src\lm4f\libraries\SPI; ..\src\lm4f\libraries\Wire; ..\src\lm4f\variants\stellarpad
  OBJCOPY.OOCOutputFile: murix-uav-iar.srec
  ILINK.IlinkOutputFile: murix-uav-iar.out
  ILINK.IlinkIcfFile: murix-uav-iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src/bitlash
    ../src/bitlash/: bitlash.cpp bitlash.h
  group src/freertos
    ../src/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group src/freertos/portable
    ../src/freertos/portable/MemMang/: heap_4.c
    ../src/freertos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group src/lm4f/cores/lm4f
    ../src/lm4f/cores/lm4f/: Arduino.h binary.h Client.h Energia.h HardwareSerial.cpp HardwareSerial.h IPAddress.cpp IPAddress.h itoa.c itoa.h main.cpp new.cpp new.h Print.cpp Print.h Printable.h random.c Server.h startup_gcc.c Stream.cpp Stream.h Tone.cpp Udp.h WCharacter.h WInterrupts.c wiring.c wiring_analog.c wiring_digital.c wiring_private.h wiring_pulse.c wiring_shift.c WMath.cpp WString.cpp WString.h
  group src/lm4f/cores/lm4f/driverlib
    ../src/lm4f/cores/lm4f/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h epi_workaround_ccs.s flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group src/lm4f/libraries/AIR_BOOST_433
    ../src/lm4f/libraries/AIR_BOOST_433/: AIR430BoostFCC.h
  group src/lm4f/libraries/AIR_BOOST_433/utility
    ../src/lm4f/libraries/AIR_BOOST_433/utility/: A110LR09.cpp A110LR09.h A110LR09Config.h A110x2500.h A110x2500Radio.cpp A110x2500Radio.h CC1101.c CC1101.h Platform.cpp Platform.h
  group src/lm4f/libraries/EEPROM
    ../src/lm4f/libraries/EEPROM/: EEPROM.h EEPROM_.cpp
  group src/lm4f/libraries/SPI
    ../src/lm4f/libraries/SPI/: SPI.cpp SPI.h
  group src/lm4f/libraries/Wire
    ../src/lm4f/libraries/Wire/: Wire.cpp Wire.h
  group src/lm4f/variants/stellarpad
    ../src/lm4f/variants/stellarpad/: part.h pins_energia.h
  group src/murix
    ../src/murix/: cc1101_murix.cpp cc1101_regs.h FreeRTOSConfig.h GY521.cpp GY521.h murix_pid.cpp murix_pid.h murixdrone.cpp murixdrone.h prvGetRegistersFromStack.cpp prvGetRegistersFromStack.h sketch.cpp vApplicationStackOverflowHook.cpp
