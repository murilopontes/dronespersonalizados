# IAR project Backup of murix-iot.ewp, settings and files
configuration murix-iot-lm4f120xl (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARDUINO=150; ewarm
  ICCARM.CCIncludePath2: src\bitlash; src\lm4f\variants\stellarpad; src\lm4f\cores\lm4f; src\lm4f\libraries\I2Cdev; src\lm4f\libraries\Wire; src\lm4f\libraries\MPU6050; src\freertos; src\freertos\Source\include; src\freertos\Source\portable\IAR\ARM_CM4F; src\arduino_uip; src\arduino_uip\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: src\freertos
  OBJCOPY.OOCOutputFile: murix-iot.hex
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: src\murix-ek-lm4f120xl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src/bitlash-v2.0
    src/bitlash/: bitlash.cpp bitlash.h
  group src/bitlash-v2.0/src
    src/bitlash/src/: bitlash-api.c bitlash-builtins.c bitlash-cmdline.c bitlash-eeprom.c bitlash-error.c bitlash-functions.c bitlash-instream.c bitlash-interpreter.c bitlash-parser.c bitlash-serial.c bitlash-taskmgr.c bitlash.h eeprom.c
  group src/freertos (8.0.0)
    src/freertos/: FreeRTOSConfig.h
  group src/freertos (8.0.0)/Source
    src/freertos/Source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group src/freertos (8.0.0)/Source/include
    src/freertos/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
  group src/freertos (8.0.0)/Source/portable/IAR/ARM_CM4F
    src/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group src/freertos (8.0.0)/Source/portable/MemMang
    src/freertos/Source/portable/MemMang/: heap_4.c
  group src/lm4f (energia-0101E0011)/cores/lm4f
    src/lm4f/cores/lm4f/: Arduino.h binary.h Client.h Energia.h HardwareSerial.cpp HardwareSerial.h IPAddress.cpp IPAddress.h itoa.c itoa.h main.cpp new.cpp new.h Print.cpp Print.h Printable.h random.c startup_ewarm.cpp startup_gcc.c Stream.cpp Stream.h Tone.cpp WCharacter.h WInterrupts.c wiring.c wiring_analog.c wiring_digital.c wiring_private.h wiring_pulse.c wiring_shift.c WMath.cpp WString.cpp WString.h
  group src/lm4f (energia-0101E0011)/cores/lm4f/driverlib
    src/lm4f/cores/lm4f/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h epi_workaround_ccs.s ethernet.c ethernet.h fan.c fan.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h i2s.c i2s.h interrupt.c interrupt.h lcd.c lcd.h lpc.c lpc.h mpu.c mpu.h peci.c peci.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group src/lm4f (energia-0101E0011)/cores/lm4f/inc
    src/lm4f/cores/lm4f/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_ethernet.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_i2s.h hw_ints.h hw_lcd.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h inc.sgxx lm4f120h5qr.h tm4c123gh6pm.h
  group src/lm4f (energia-0101E0011)/libraries/EEPROM
    src/lm4f/libraries/EEPROM/: EEPROM.cpp EEPROM.h EEPROM_iar.cpp
  group src/lm4f (energia-0101E0011)/libraries/SPI
    src/lm4f/libraries/SPI/: SPI.cpp SPI.h
  group src/lm4f (energia-0101E0011)/libraries/Wire
    src/lm4f/libraries/Wire/: Wire.cpp Wire.h
  group src/lm4f (energia-0101E0011)/variants/stellarpad
    src/lm4f/variants/stellarpad/: pins_energia.h
  group src/sketch (murix-iot)
    src/sketch/: pitches.h sketch.cpp task_adc.cpp task_adc.h task_bitlash.cpp task_bitlash.h task_buttons.cpp task_buttons.h task_esc_program_card.cpp task_esc_program_card.h task_hmc5883l.cpp task_hmc5883l.h task_leds.cpp task_leds.h task_mpu6050_dmp.cpp task_mpu6050_dmp.h
